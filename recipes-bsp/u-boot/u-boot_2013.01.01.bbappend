PR_append = ".0"

UBOOT_SUFFIX := "img"
SPL_BINARY := "MLO"
