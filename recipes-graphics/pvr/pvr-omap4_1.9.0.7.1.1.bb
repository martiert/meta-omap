# Copyright (C) 2013 Martin Ertsaas <mertsas@cisco.com>
# Released under the MIT license (see COPYING.MIT for the terms)

require pvr-omap4.inc

LIC_FILES_CHKSUM = "file://debian/copyright;md5=542af8025bb26f9b36a120c00e319748"

SRCREV = "0082fdce1b966620de286bdd89da7b818ad28f2f"
SRC_URI = "git://gitorious.org/ubuntu-omap/pvr-omap4.git"
