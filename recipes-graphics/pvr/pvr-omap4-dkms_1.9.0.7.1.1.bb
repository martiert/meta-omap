# Copyright (C) 2013 Martin Ertsaas <mertsas@cisco.com>
# Released under the MIT license (see COPYING.MIT for the terms)

require pvr-omap4-dkms.inc

LIC_FILES_CHKSUM = "file://GPL-COPYING;md5=60422928ba677faaa13d6ab5f5baaa1e \
                    file://MIT-COPYING;md5=8c2810fa6bfdc5ae5c15a0c1ade34054 \
                    "
SRCREV = "a2698ddbcdc4c061442562d415e7a304b4ba85a8"
SRC_URI = "git://gitorious.org/ubuntu-omap/pvr-omap4-dkms.git"
